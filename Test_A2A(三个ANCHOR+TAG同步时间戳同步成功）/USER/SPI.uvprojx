# Keil uVision project SPI.uvprojx, settings and files
target TREK1000 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\SPI;..\HARDWARE\application;..\HARDWARE\decadriver;..\HARDWARE\platform;..\HARDWARE\compiler;..\HARDWARE\PORT;..\HARDWARE\stm32flash;..\HARDWARE\DMA;..\USB\lib;..\USB\src;..\Public
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../HARDWARE/application/: instance.c instance_calib.c instance_common.c
  group decadriver
    ../HARDWARE/decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group platform
    ../HARDWARE/platform/: deca_mutex.c deca_spi.c device_info.c
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PORT/: port.c
    ../HARDWARE/stm32flash/: stmflash.c
    ../STM32F10x_FWLib/src/: stm32f10x_tim.c
  group USB
    ../USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/Lib
    ../USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/DMA/: dma.c
    ../Public/: Queue.c
  group NOTE
    ../: README.TXT
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
